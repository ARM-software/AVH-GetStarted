# Keil uVision project Blinky.uvprojx, settings and files
target Corstone-310 (6180000::V6.18::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0-dev39
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM85\ARMCM85_ac6.sct
  group Source
    ./: main.c
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
